# Keil uVision project DEMO-AD5700D2Z.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: DEMO-AD5700D2Z +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup code
    ./: startup_ADuCM360.s
  group Application
    ./: DEMO-AD5700D2Z.c GPIO.c CLK.c TIMER.c AFE.c AD5421.c SPI.c FLASH.c UART.c RETARGET.c INTERRUPTS.c
  group Libraries
    ./: DEMO-AD5700D2Z_HART.lib
