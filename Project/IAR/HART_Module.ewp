# IAR project HART_Module.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM360 AnalogDevices ADuCM360
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\inc\common; ..\..\inc; $TOOLKIT_DIR$\CMSIS\Include; $TOOLKIT_DIR$\inc\AnalogDevices; ..\..\inc\G_LCD
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HART_Module.hex
  ILINK.IlinkOutputFile: HART_Module.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../inc/common/IAR/: startup_ADuCM360.s
  group common
    ../../inc/common/: ClkLib.c DioLib.c GptLib.c IntLib.c UrtLib.c WdtLib.c
    ../../inc/: HART.c
  group src
    ../../src/: main.c
